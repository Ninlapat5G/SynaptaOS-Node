## examples/02_MultiDevice/sdkconfig.defaults
```kconfig
CONFIG_MQTT_PROTOCOL_5=y
CONFIG_MQTT_TRANSPORT_SSL=y
CONFIG_LWIP_DNS_SUPPORT_MDNS_QUERIES=y
```
